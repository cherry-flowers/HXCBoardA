# Keil uVision project HXCBoardA.uvprojx, settings and files
target HXCBoardA (6180000::V6.18::ARMCLANG)
  device: STM32F427VITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: HXCBoardA
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_HAL_DRIVER,STM32F427xx
  c include: .;Core\Inc;Drivers\STM32F4xx_HAL_Driver\Inc;Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;Middlewares\Third_Party\FreeRTOS\Source\include;Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS_V2;Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;Drivers\CMSIS\Device\ST\STM32F4xx\Include;Drivers\CMSIS\Include;.cmsis\include;MDK-ARM\RTE\_HXCBoardATest_FreeRTOS_F427VIT6;User\App\Inc;User\Bsp\Inc;User\Lib\Inc;User\B2MW\Inc;User\MiddleWare\B2MW\Inc;User\MiddleWare\MWCommon\Inc;User\MiddleWare\Elrs\Inc;User\MiddleWare\Log\Inc
  asm define: USE_HAL_DRIVER,STM32F427xx
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER/MIDDLEWARE/MWCOMMON/SRC
    User/MiddleWare/MWCommon/Src/: MW_AssertStatus.cpp
  group USER/MIDDLEWARE/LOG/SRC
    User/MiddleWare/Log/Src/: Log.cpp
  group USER/MIDDLEWARE/B2MW/SRC
    User/MiddleWare/B2MW/Src/: B2MW_CANManager.cpp B2MW_Timer.cpp
  group USER/BSP/SRC
    User/Bsp/Src/: BspCan.cpp BspDevice.cpp BspPwm.cpp BspSpi.cpp BspTimer.cpp BspUart.cpp
  group USER/APP/SRC
    User/App/Src/: Callback.cpp user_main.cpp
  group USER/LIB/SRC
    User/Lib/Src/: dwt.c
  group Middlewares/FreeRTOS
    Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Drivers/CMSIS
    Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Application/User/Core
    Core/Src/: main.c gpio.c freertos.c adc.c can.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c dma.c
  group Application/MDK-ARM
    MDK-ARM/: startup_stm32f427xx.s
  group MOTOR
    ./User/MiddleWare/Motor/DJImotor/DJI3508/Src/: DJI3508.cpp
    ./User/MiddleWare/Motor/DMmotor/DMJ4310_2EC/Src/: DMJ4310.cpp
    ./User/MiddleWare/Motor/DMmotor/DMJ10010L_2EC/Src/: DMJ10010L.cpp
  group USER/MIDDLEWARE/ELRS/SRC
    ./User/MiddleWare/Elrs/Src/: elrs.cpp
  group Algorithm
    ./User/MiddleWare/Algorithm/Src/: Fuzzy_PID_Controller.cpp LowPassFilter.cpp MW_Math.cpp PID_Controller.cpp
